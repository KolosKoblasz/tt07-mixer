v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
